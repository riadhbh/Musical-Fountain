# IAR project Musical_Fountain.ewp, settings and files
configuration Musical_Fountain (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src; ..\..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Musical_Fountain.srec
  ILINK.IlinkOutputFile: Musical_Fountain.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Musical_Fountain/STM32F4xx_StdPeriph_Driver/inc/: main.h Pumps.h stm32f4xx_tim.h
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/inc/: VuMeter.h
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: Pumps.c stm32f4xx_usart.c VuMeter.c
